# Repository KaiPereira/SODIMM-CM5-Carrier (continued)

## KiCad design PCB_CARRIER/carrier.kicad_pcb (continued)

Board: 6 copper layers, 69.6 x 46.1 mm, 98 parts (0 on the bottom side), 191 nets.

File PCB_CARRIER/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C10, C14, C15, C17, C19, C2, C3, C4, C5, C6",0402,11,0.1uF,
"C11, C20",0603,2,10uF,
"C12, C13, C16, C18, C7, C8, C9",0402,7,1uF,
D1,0805,1,Green,
D2,0805,1,Yellow,
J1,SODIMM_DDR4_EDGE,1,SODIMM-260_Split,
J2,microSD_HC_Hirose_DM3AT-SF-PEJM5,1,Micro_SD_Card_Det2,
MODULE1,Raspberry-Pi-4-Compute-Module-B,1,Mezzanine_B,2x DF40C-100DS-0.4V
MODULE2,Raspberry-Pi-4-Compute-Module-A,1,Mezzanine_A,2x DF40C-100DS-0.4V
"Q2, Q3, Q5",SOT-23-3,3,BSS138,
Q4,SOT-323_SC-70,1,BC817-40,
"R1, R15",0402,2,330,
"R10, R11, R12, R13, R16, R17, R18, R19, R2, R20, R21, R24, R25, R5, R6, R7, R8, R9",0402,18,10K,
R14,0402,1,12K,
"R22, R23, R26, R27, R28, R29, R3, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39, R4, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R60, R61",0402,40,0,
SW1,SW_DIP_SPSTx04_Slide_Copal_CHS-04B_W7.62mm_P1.27mm,1,SW_DIP_x04,
TP1,TestPoint_Pad_D1.0mm,1,RTC Test,
TP2,TestPoint_Pad_D1.0mm,1,Sleep Status Output,
"U1, U2, U3",TSSOP-24_4.4x5mm_P0.4mm,3,SN74LVC8T245,
U4,TSOT-23-5,1,RT9742GGJ5,

## Commit log (part)

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2025-09-02 added the SODIMM connector in
2025-09-02 forgot to move image!
2025-09-02 updating every single symbol to be more accurate!
2025-09-02 updated journal with my stupidity
2025-09-02 cleaning up stuff so it's not all messy
2025-09-02 updated every single symbol to put a/b at the start
2025-09-02 working on getting all the grounds into SODIMM
2025-09-02 all the ground SODIMM's have been wired up
2025-09-02 updating the images in my journal
2025-09-02 adding in the power pins, this is going to take a long time...
2025-09-02 added decoupling to power lines on the daughter card
2025-09-02 added decoupling for power on the daughter card
2025-09-02 added usb labels in
2025-09-02 wired the USB pins
2025-09-02 finished wiring USB
2025-09-03 labelled ethernet on the mezzanine connectors, but just not the LED's
2025-09-03 added ethernet ot the SODIMM
2025-09-03 fixed schematic for ethernet
2025-09-03 update journal with ethernet
2025-09-03 added in the missing usb lines, whoops
2025-09-03 changed the direction of everything and all the pins should be good now, close call!
2025-09-03 fixed journal images, I really need to setup an automation for this...
2025-09-03 added in the fan pins
2025-09-03 starting on day 8
2025-09-03 fixed the dire ction of like ALL the labels AGAIN
2025-09-03 Moved HPD, added CEC
2025-09-03 fixed images
2025-09-04 working on the SD card
2025-09-04 rough draft but sd cards working
2025-09-04 refined sd cards a bit more
2025-09-04 added sd card to journal
2025-09-05 added some BMC stuff to sd card
2025-09-06 working on NVMe SSD
2025-09-06 reverting SODIMM symbol because I was wrong about the pinout
2025-09-06 working on routing the NVMe SSD socket
2025-09-06 finished wiring the NVMe SSD
2025-09-06 put usb otg floating, and changed some labels to make stuff more clear
2025-09-06 gave some background information for the PCIe NVMe SSD
2025-09-06 I think I'm going to wire the NVMe SSD through the SODIMM connector
2025-09-06 fix images on the board
2025-09-07 starting to route PCIe to the SODIMM
2025-09-07 updated journal with breaking out PCIe
2025-09-07 updating power net labels to just power labels
2025-09-09 starting cameras
2025-09-09 more camera stuff
2025-09-09 changing camera shapes and adding I2C
2025-09-09 finished breaking out the camera to the SODIMM
2025-09-09 more camera stuff in the journal
2025-09-09 fixing journal images
2025-09-09 finish day 9
2025-09-10 working on SODIMM connector
2025-09-10 added SODIMM footprint
2025-09-10 updating journal with gold fingers
2025-09-10 add sd card journal entry
2025-09-10 aligning SODIMM connector
2025-09-10 add edge cuts for daughter board
2025-09-11 updated journal with CM5 positioning
2025-09-16 adding some caps in
2025-09-16 more decoupling stuff
2025-09-16 added a bunch of PCIe no connects
2025-09-16 aligning passives and SD card
2025-09-17 added more passives/led's
2025-09-17 ending off the day in the journal
2025-09-17 fixing the SPI 0, I'm also eating some really good korean grapes right now
2025-09-18 spi 1
2025-09-18 some spi background
2025-09-18 update journal
2025-09-18 UART 1
2025-09-18 UART 0
2025-09-18 UART 3
2025-09-18 starting to wire the second camera
2025-09-18 cleaning up SPI labels
2025-09-18 added CSI 1
2025-09-18 change direction of camera pins
2025-09-19 added an I2C bus
2025-09-19 adding some background, tuning out for the day!
2025-09-19 update progrress for school!
2025-09-19 worked on the decoupling and layout
2025-09-20 adding no-connects and working on GPIO's
2025-09-20 starting day 12 :DDDD and working on GPIO's
2025-09-20 wiring power EN and PMIC VBAT
2025-09-20 added sleep/wake and sys_reset
2025-09-21 working on NMOS power circuit
2025-09-21 added hiearchial sheet for NMOS
2025-09-21 nRPI boot wiring
2025-09-21 adding EEPROM_nWP
2025-09-21 remapping reset, not done yet
2025-09-22 added system reset
2025-09-22 adding shutdown req
2025-09-22 remove EEPROM and add button for reset
2025-09-22 adding mod_sleep and removing one of the free GPIO's
2025-09-22 adding power LED
2025-09-22 all pins used on the GPIO mezzanine finallygit add .!
2025-09-22 all mezzanine pins used
2025-09-23 removing GPIO with camera powerdown, I might want to actually break out some of these used GPIO's to be free io's though
2025-09-23 adding back my journal, blueprint is jank
2025-09-23 added components to the pcb
2025-09-23 placement and moved LED's, procrastinating in class like always
2025-09-23 redoing layout a bit more
2025-09-23 re-organized the GPIO mezzanine schematic
2025-09-24 working on level shifting
2025-09-24 hopping off for the night, but I'm sincerely almost done the wiring
2025-09-24 add buttons to journal
2025-09-24 finished day 12
2025-09-24 going to school now
2025-10-03 fixed camera power pins, oops, researching a lot about level shifting
2025-10-04 labelling SPI bidirectional, this is really cooking my head
2025-10-04 SPI level shift components, I think I finally got this down
2025-10-04 fixing SPI label direction, and changing level shifting
2025-10-04 SPI inputs to level shift
2025-10-04 fixed SPI, mislabelled some stuff
2025-10-04 added passives
2025-10-04 fixed dir mode
2025-10-04 re-naming all UART signals for shifting preparation
2025-10-04 level shifted UART
2025-10-05 level shifting UART
2025-10-05 only GPIO0 left to level shift, so I kinda wanna figure out a different way without adding a bidirectional shifter, but pwm and tach are in now
2025-10-05 making schematic a bit more clean
2025-10-05 fixed all the images in my journal, I can't believe that level shifting is done now, onto termination resistors
2025-10-05 starting work on terminators and ESD protection
2025-10-05 created a pinout table
2025-10-07 cross checking every pin, that took awhile
2025-10-07 talking about some of the stats
2025-10-07 talking about impedance
2025-10-07 talking about USB3.0 routing design
2025-10-08 PCIe gen 3.0 design specs
2025-10-08 talking about stripline/microstrip
2025-10-08 added HDMI design
2025-10-08 fixing ERC
2025-10-09 fix merge conflicts
2025-10-09 sd card pullups
2025-10-10 starting on damping resistors
2025-10-10 starting damping
2025-10-12 terminations on USB M/P
2025-10-12 dampened CSI0
2025-10-12 footprints for passives
2025-10-12 level shifter footprints, holy these are expensive
2025-10-12 fixed dampening resistors, decent commit to revert too
2025-10-13 fixing images
2025-10-13 started to align all the resistors
2025-10-13 organizing more components
2025-10-13 organizing all the components
2025-10-13 working on layout, labelled buttons
2025-10-13 ground fill and moving components
2025-10-13 working on back journaling
2025-10-13 writing about dampening resistors
2025-10-13 journaled the footprints
2025-10-13 working on testing points
2025-10-14 finished adding test points
2025-10-14 sync for school
2025-10-14 updated button
2025-10-15 adding PDF :D
2025-10-15 renaming all labels to use N instead of M
2025-10-17 changed the board stackup, doing LOTS of research on how EMI/Signal integrity works
2025-10-19 starting to route differential pairs, I'M FINALLY READY >:)
2025-10-19 optimizing PCIe netclasses, still learning how this works!
2025-10-19 flipped connector so it's easier to route
2025-10-20 working on my journal
2025-10-21 pushing for school
2025-10-29 messing around with settings for the antipad and proper high speed routing, refer to previous commits for previous settings if off
2025-10-29 starting voiding under pads
2025-10-29 even more optimal PCIe routing
2025-10-29 forgot to save
2025-10-30 routed PCIe and started USB 3.0
2025-10-30 better routing
2025-10-30 more routing
2025-10-31 more damping resistors on HDMI CLK, and organizing some resistors
2025-10-31 added HDMI netclass
2025-10-31 finished CSI netclass
2025-11-01 trying to route HDMI, not going too well though
2025-11-01 length matched HDMI, but fumbled and made it too close to the SODIMM connector
2025-11-01 trying to give my signals enough space, this is going to take a while
2025-11-01 some nice routing!
2025-11-01 Routing is coming along better
2025-11-01 fixing some images
2025-11-02 better routing, this is beautiful
2025-11-02 tuning some skew
2025-11-02 placing CSI dampening resistors
2025-11-02 starting to describe HDMI
2025-11-02 routing CSI, adjusting some of the HDMI stuff to make way for more traces
2025-11-02 added back skew tuning
2025-11-02 holy routing
2025-11-03 yes I'm still routing CSI
2025-11-03 finished routing bottom CSI, just have to skew match now
2025-11-03 tuned skew before dampening resistors
2025-11-03 moving some stuff so I can connect grounds, HDMI routing a bit sketchy
2025-11-03 updated journal for today, got so much done
2025-11-03 fixing journal
2025-11-04 still cleaning up HDMIg
2025-11-04 looking good
2025-11-04 tuning skew on HDMI pairs
2025-11-04 updated journal with today!
2025-11-04 actually re-routing low-speeds though
2025-11-04 re-routing HDMI after dampening resistors, length matched too
2025-11-04 heading off to school - maybe
2025-11-05 starting to level shift
2025-11-05 updating the jjournal with moving low-speeds, setting up level shifters, power and the button!
2025-11-05 fixing images :D
2025-11-05 fixed logic on both PCB and schematic :D
2025-11-05 fixing another mosfet
2025-11-05 hopping off, mosfet logic is still wrong I think
2025-11-05 fixing the PMIC mosfet
2025-11-05 saving everything from school
2025-11-06 moving level shifting pins to be easier to route
2025-11-06 changing level shifting pinout, to have an organized pinout and not pinin for easy routing to tight via's
2025-11-06 routing the SD card!
2025-11-06 re-routing USB to have less crosstalk
2025-11-06 some level shifting routing, gonna head out but work on GBe in the morning
2025-11-06 routing low speeds!
2025-11-06 more routing level shifting, almost done!
2025-11-06 starting to route out the level shifter pinout, adding dampening to SPI
2025-11-06 adding dampening resistors to SPI - schematic
2025-11-07 finished adding dampening resistors to SPI
2025-11-07 routed out a bunch of level shifters
2025-11-07 added GbE netclass to all the ethernet labels!
2025-11-07 added ethernet differential pairs
2025-11-07 routed all the level shifters!
2025-11-07 routing the SD card and some other peripherals
2025-11-08 journaling about routing low speeds, nothing exciting
2025-11-08 journaling about SPI
2025-11-08 fixing the images!
2025-11-08 only 21 more nets leftgit add .
2025-11-08 11 nets left, no long ones anymoregit add .!
2025-11-08 fixed all the DRC errors!
2025-11-08 removed all the unimportant silkscreen
2025-11-08 added all the unimportant silkscreen
2025-11-08 some finishing silkscreen touches!
2025-11-08 plotted the schematic as a pdf
2025-11-08 Adding reference schematic to readme
2025-11-09 adding production files!
2025-11-09 adding the 3D model to my mezzanine connectors
2025-11-09 adding the 3CM5 into the 3D model
2025-11-09 Adding a CM5 3D model screenshot into my readme
2025-11-09 updating my rjournal with some of the polishing things!
2025-11-09 adjusting inner layer traces to be more optimal
2025-11-09 spread out traces on top/bottom, re-routed USB 3.0 dif pairs
2025-11-10 added PDF's of the board!
2025-11-10 Added links to PDF's in readme!
2025-11-11 pcb review suggestion in journal! Gotta work on these now!
2025-11-11 update LED footprints to use 0805 to use basic parts!
2025-11-11 new production files
2025-11-11 changed the value of some resistors and fixed 2 DRC errors
2025-11-12 time to switch the mezzanine connector, saving at this point if I mess up
2025-11-12 separating mezzanine connector symbol/footprint for easy pcba, a bit sketch
2025-11-12 fixing a pesky little resistor
2025-11-12 adding the JLCPCB BOM, it's missing the switch though
2025-11-13 updating the BOM, all the parts are fine, just one off center now!
2025-11-13 new prod files!
2025-11-13 journaling about getting the checkout ready
2025-11-15 fixing the last image, getting ready for submission!
