# Repository KaiPereira/SODIMM-CM5-Carrier

File README.md:

# CM5 SO-DIMM Carrier

This SO-DIMM card essentially let's you turn a CM5 into a NVIDIA Jetson card, turing RK1, and other compatible SO-DIMM standards! It's going to be used for my future server clutser motherboard!
## Custom Features!
- Jetson/Turing RK1/Radxa/etc compatible SO-DIMM connector
- Support for SD Card mounting
- GbE Ethernet
- 1x PCIe Gen 3.0
- 2x USB 3.2 Gen 1 support, 1x USB 2.0
- 1x HDMI 2.0
- 2x 4-Lane MIPI CSI
- Misc buttons/LED's

## PCB Design

The CM5 SO-DIMM carrier is a complex 6-layer PCB, with the stackup HIGH-SPEED/GND/SIGNAL/SIGNAL/GND/HIGH-SPEED, with power running along the top layer! You can easily access the [schematic](https://github.com/KaiPereira/CM5-SODIMM-Carrier/blob/master/PCB_CARRIER/SCHEMATIC.pdf), [PCB layers](https://github.com/KaiPereira/CM5-SODIMM-Carrier/blob/master/PCB_CARRIER/PCB.pdf) and [whole PCB](https://github.com/KaiPereira/CM5-SODIMM-Carrier/blob/master/PCB_CARRIER/PCB_WHOLE.pdf) PDF's!

## KiCad design PCB_CARRIER/carrier.kicad_pcb

Parts:
R3, R4, R22, R23, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R60, R61: 0; R_0402_1005Metric

Connections:
CSI-0_CLK_N: R34.2; also elsewhere on the board
CSI-0_CLK_P: R35.2; also elsewhere on the board
CSI-0_D0_N: R36.2; also elsewhere on the board
CSI-0_D0_P: R37.2; also elsewhere on the board
CSI-0_D1_N: R38.2; also elsewhere on the board
CSI-0_D1_P: R39.2; also elsewhere on the board
CSI-0_D2_N: R40.2; also elsewhere on the board
CSI-0_D2_P: R41.2; also elsewhere on the board
CSI-0_D3_N: R42.2; also elsewhere on the board
CSI-0_D3_P: R43.2; also elsewhere on the board
CSI-1_CLK_N: R44.2; also elsewhere on the board
CSI-1_CLK_P: R45.2; also elsewhere on the board
CSI-1_D0_N: R46.2; also elsewhere on the board
CSI-1_D0_P: R47.2; also elsewhere on the board
CSI-1_D1_N: R48.2; also elsewhere on the board
CSI-1_D1_P: R49.2; also elsewhere on the board
CSI-1_D2_N: R50.2; also elsewhere on the board
CSI-1_D2_P: R51.2; also elsewhere on the board
CSI-1_D3_N: R52.2; also elsewhere on the board
CSI-1_D3_P: R53.2; also elsewhere on the board
HDMI-0_CLK_N: R22.1; also elsewhere on the board
HDMI-0_CLK_P: R23.1; also elsewhere on the board
HDMI-0_TX0_N: R28.1; also elsewhere on the board
HDMI-0_TX0_P: R29.1; also elsewhere on the board
HDMI-0_TX1_N: R30.1; also elsewhere on the board
HDMI-0_TX1_P: R31.1; also elsewhere on the board
HDMI-0_TX2_N: R32.1; also elsewhere on the board
HDMI-0_TX2_P: R33.1; also elsewhere on the board
SPI-0_CLK_3V3: R3.1; also elsewhere on the board
SPI-0_CS0_3V3: R4.1; also elsewhere on the board
SPI-0_CS1_3V3: R54.1; also elsewhere on the board
SPI-0_MISO_3V3: R55.1; also elsewhere on the board
SPI-0_MOSI_3V3: R56.1; also elsewhere on the board
SPI-1_CLK_3V3: R57.1; also elsewhere on the board
SPI-1_CS0_3V3: R58.1; also elsewhere on the board
SPI-1_CS1_3V3: R59.1; also elsewhere on the board
SPI-1_MISO_3V3: R60.1; also elsewhere on the board
SPI-1_MOSI_3V3: R61.1; also elsewhere on the board
USB_N: R26.1; also elsewhere on the board
USB_P: R27.1; also elsewhere on the board
dCSI-0_CLK_N: R34.1; also elsewhere on the board
dCSI-0_CLK_P: R35.1; also elsewhere on the board
dCSI-0_D0_N: R36.1; also elsewhere on the board
dCSI-0_D0_P: R37.1; also elsewhere on the board
dCSI-0_D1_N: R38.1; also elsewhere on the board
dCSI-0_D1_P: R39.1; also elsewhere on the board
dCSI-0_D2_N: R40.1; also elsewhere on the board
dCSI-0_D2_P: R41.1; also elsewhere on the board
dCSI-0_D3_N: R42.1; also elsewhere on the board
dCSI-0_D3_P: R43.1; also elsewhere on the board
dCSI-1_CLK_N: R44.1; also elsewhere on the board
dCSI-1_CLK_P: R45.1; also elsewhere on the board
dCSI-1_D0_N: R46.1; also elsewhere on the board
dCSI-1_D0_P: R47.1; also elsewhere on the board
dCSI-1_D1_N: R48.1; also elsewhere on the board
dCSI-1_D1_P: R49.1; also elsewhere on the board
dCSI-1_D2_N: R50.1; also elsewhere on the board
dCSI-1_D2_P: R51.1; also elsewhere on the board
dCSI-1_D3_N: R52.1; also elsewhere on the board
dCSI-1_D3_P: R53.1; also elsewhere on the board
dHDMI-0_CLK_N: R22.2; also elsewhere on the board
dHDMI-0_CLK_P: R23.2; also elsewhere on the board
dHDMI-0_TX0_N: R28.2; also elsewhere on the board
dHDMI-0_TX0_P: R29.2; also elsewhere on the board
dHDMI-0_TX1_N: R30.2; also elsewhere on the board
dHDMI-0_TX1_P: R31.2; also elsewhere on the board
dHDMI-0_TX2_N: R32.2; also elsewhere on the board
dHDMI-0_TX2_P: R33.2; also elsewhere on the board
dSPI-0_CLK_3V3: R3.2; also elsewhere on the board
dSPI-0_CS0_3V3: R4.2; also elsewhere on the board
dSPI-0_CS1_3V3: R54.2; also elsewhere on the board
dSPI-0_MISO_3V3: R55.2; also elsewhere on the board
dSPI-0_MOSI_3V3: R56.2; also elsewhere on the board
dSPI-1_CLK_3V3: R57.2; also elsewhere on the board
dSPI-1_CS0_3V3: R58.2; also elsewhere on the board
dSPI-1_CS1_3V3: R59.2; also elsewhere on the board
dSPI-1_MISO_3V3: R60.2; also elsewhere on the board
dSPI-1_MOSI_3V3: R61.2; also elsewhere on the board
dUSB_N: R26.2; also elsewhere on the board
dUSB_P: R27.2; also elsewhere on the board

Parts:
C3, C10, C14, C15, C17, C19: 0.1uF; C_0402_1005Metric
C8, C9, C12, C13, C16, C18: 1uF; C_0402_1005Metric
R2, R5, R6, R7, R8, R9: 10K; R_0402_1005Metric
U1, U2, U3: SN74LVC8T245; TSSOP-24_4.4x5mm_P0.4mm

Connections:
+1V8: C3.2, C8.2, C13.2, C15.2, C16.1, C17.1, U1.1 (V_{CCA}), U2.1 (V_{CCA}), U3.23 (V_{CCB}), U3.24 (V_{CCB}); also elsewhere on the board
+3V3: C9.1, C10.1, C12.2, C14.2, C18.1, C19.1, U1.23 (V_{CCB}), U1.24 (V_{CCB}), U2.23 (V_{CCB}), U2.24 (V_{CCB}), U3.1 (V_{CCA}); also elsewhere on the board
FAN_PWM_1V8: U2.8 (A6); also elsewhere on the board
FAN_PWM_3V3: U2.16 (B6); also elsewhere on the board
FAN_TACH_1V8: U3.19 (B3); also elsewhere on the board
FAN_TACH_3V3: U3.5 (A3); also elsewhere on the board
GND: C3.1, C8.1, C9.2, C10.2, C12.1, C13.1, C14.1, C15.1, C16.2, C17.2, C18.2, C19.2, R2.2, R5.2, R6.2, R7.2, R8.2, R9.2, U1.11 (GND), U1.12 (GND), U1.13 (GND), U2.10 (A8), U2.11 (GND), U2.12 (GND), U2.13 (GND), U2.14 (B8), U3.11 (GND), U3.12 (GND), U3.13 (GND); also elsewhere on the board
GPIO0_1V8: U2.3 (A1); also elsewhere on the board
GPIO0_3V3: U2.21 (B1); also elsewhere on the board
unnamed: R2.1, U1.2 (DIR)
unnamed: R5.1, U1.22 (~OE)
unnamed: R8.1, U2.2 (DIR)
unnamed: R9.1, U2.22 (~OE)
unnamed: R6.1, U3.2 (DIR)
unnamed: R7.1, U3.22 (~OE)
SPI-0_CLK_1V8: U1.4 (A2); also elsewhere on the board
SPI-0_CS0_1V8: U1.5 (A3); also elsewhere on the board
SPI-0_CS1_1V8: U1.6 (A4); also elsewhere on the board
SPI-0_MISO_1V8: U3.14 (B8); also elsewhere on the board
SPI-0_MOSI_1V8: U1.3 (A1); also elsewhere on the board
SPI-1_CLK_1V8: U1.7 (A5); also elsewhere on the board
SPI-1_CS0_1V8: U1.10 (A8); also elsewhere on the board
SPI-1_CS1_1V8: U1.9 (A7); also elsewhere on the board
SPI-1_MISO_1V8: U3.17 (B5); also elsewhere on the board
SPI-1_MOSI_1V8: U1.8 (A6); also elsewhere on the board
UART-0_CTS_1V8: U3.16 (B6); also elsewhere on the board
UART-0_CTS_3V3: U3.8 (A6); also elsewhere on the board
UART-0_RTS_1V8: U2.5 (A3); also elsewhere on the board
UART-0_RTS_3V3: U2.19 (B3); also elsewhere on the board
UART-0_RX_1V8: U3.15 (B7); also elsewhere on the board
UART-0_RX_3V3: U3.9 (A7); also elsewhere on the board
UART-0_TX_1V8: U2.4 (A2); also elsewhere on the board
UART-0_TX_3V3: U2.20 (B2); also elsewhere on the board
UART-1_CTS_1V8: U3.20 (B2); also elsewhere on the board
UART-1_CTS_3V3: U3.4 (A2); also elsewhere on the board
UART-1_RTS_1V8: U2.7 (A5); also elsewhere on the board
UART-1_RTS_3V3: U2.17 (B5); also elsewhere on the board
UART-1_RX_1V8: U3.18 (B4); also elsewhere on the board
UART-1_RX_3V3: U3.6 (A4); also elsewhere on the board
UART-1_TX_1V8: U2.6 (A4); also elsewhere on the board
UART-1_TX_3V3: U2.18 (B4); also elsewhere on the board
UART-2_RX_1V8: U3.21 (B1); also elsewhere on the board
UART-2_RX_3V3: U3.3 (A1); also elsewhere on the board
UART-2_TX_1V8: U2.9 (A7); also elsewhere on the board
UART-2_TX_3V3: U2.15 (B7); also elsewhere on the board
dSPI-0_CLK_3V3: U1.20 (B2); also elsewhere on the board
dSPI-0_CS0_3V3: U1.19 (B3); also elsewhere on the board
dSPI-0_CS1_3V3: U1.18 (B4); also elsewhere on the board
dSPI-0_MISO_3V3: U3.10 (A8); also elsewhere on the board
dSPI-0_MOSI_3V3: U1.21 (B1); also elsewhere on the board
dSPI-1_CLK_3V3: U1.17 (B5); also elsewhere on the board
dSPI-1_CS0_3V3: U1.14 (B8); also elsewhere on the board
dSPI-1_CS1_3V3: U1.15 (B7); also elsewhere on the board
dSPI-1_MISO_3V3: U3.7 (A5); also elsewhere on the board
dSPI-1_MOSI_3V3: U1.16 (B6); also elsewhere on the board

Notes on the sheet:
TRANSMIT SPI
Receive SPI/UART/TACH
Transmit UART/PWM/GPIO0
< GPIO0 is transmit only to save on IC's

Parts:
J1: SODIMM-260_Split; SODIMM_DDR4_EDGE

Connections:
+5V: J1.251, J1.252, J1.253, J1.254, J1.255, J1.256, J1.257, J1.258, J1.259, J1.260; also elsewhere on the board
CSI-0_PWDN: J1.114; also elsewhere on the board
CSI-0_SCL: J1.213; also elsewhere on the board
CSI-0_SDA: J1.215; also elsewhere on the board
CSI-1_PWDN: J1.120; also elsewhere on the board
FAN_PWM_1V8: J1.230; also elsewhere on the board
FAN_TACH_1V8: J1.208; also elsewhere on the board
GBE_LED_ACT: J1.194; also elsewhere on the board
GBE_LED_LINK: J1.188; also elsewhere on the board
GBE_MDI0_N: J1.184; also elsewhere on the board
GBE_MDI0_P: J1.186; also elsewhere on the board
GBE_MDI1_N: J1.190; also elsewhere on the board
GBE_MDI1_P: J1.192; also elsewhere on the board
GBE_MDI2_N: J1.196; also elsewhere on the board
GBE_MDI2_P: J1.198; also elsewhere on the board
GBE_MDI3_N: J1.202; also elsewhere on the board
GBE_MDI3_P: J1.204; also elsewhere on the board
GND: J1.1, J1.2, J1.7, J1.8, J1.13, J1.14, J1.19, J1.20, J1.25, J1.26, J1.31, J1.32, J1.37, J1.38, J1.43, J1.44, J1.49, J1.50, J1.55, J1.56, J1.61, J1.62, J1.67, J1.68, J1.73, J1.74, J1.79, J1.80, J1.85, J1.86, J1.102, J1.107, J1.113, J1.119, J1.125, J1.129, J1.132, J1.135, J1.138, J1.141, J1.144, J1.146, J1.147, J1.152, J1.153, J1.158, J1.159, J1.164, J1.165, J1.170, J1.171, J1.176, J1.177, J1.200, J1.201, J1.231, J1.241, J1.242, J1.243, J1.244, J1.245, J1.246, J1.247, J1.248, J1.249, J1.250; also elsewhere on the board
GPIO0_1V8: J1.87; also elsewhere on the board
HDMI-0_CEC: J1.94; also elsewhere on the board
HDMI-0_HPD: J1.96; also elsewhere on the board
HDMI-0_SCL: J1.100; also elsewhere on the board
HDMI-0_SDA: J1.98; also elsewhere on the board
I2C-0_SCL: J1.185; also elsewhere on the board
I2C-0_SDA: J1.187; also elsewhere on the board
MOD_SLEEP: J1.178; also elsewhere on the board
PCIe_CLKREQ: J1.180; also elsewhere on the board
PCIe_CLK_N: J1.160; also elsewhere on the board
PCIe_CLK_P: J1.162; also elsewhere on the board
PCIe_RX_N: J1.131; also elsewhere on the board
PCIe_RX_P: J1.133; also elsewhere on the board
PCIe_TX_N: J1.134; also elsewhere on the board
PCIe_TX_P: J1.136; also elsewhere on the board
PCIe_nRST: J1.181; also elsewhere on the board
POWER_BMC: J1.237; also elsewhere on the board
RESET_BMC: J1.239; also elsewhere on the board
SHUT_REQ_BMC: J1.233; also elsewhere on the board
SLEEP/WAKE: J1.240; also elsewhere on the board
SPI-0_CLK_1V8: J1.91; also elsewhere on the board
SPI-0_CS0_1V8: J1.95; also elsewhere on the board
SPI-0_CS1_1V8: J1.97; also elsewhere on the board
SPI-0_MISO_1V8: J1.93; also elsewhere on the board
SPI-0_MOSI_1V8: J1.89; also elsewhere on the board
SPI-1_CLK_1V8: J1.106; also elsewhere on the board
SPI-1_CS0_1V8: J1.110; also elsewhere on the board
SPI-1_CS1_1V8: J1.112; also elsewhere on the board
SPI-1_MISO_1V8: J1.108; also elsewhere on the board
SPI-1_MOSI_1V8: J1.104; also elsewhere on the board
UART-0_CTS_1V8: J1.105; also elsewhere on the board
UART-0_RTS_1V8: J1.103; also elsewhere on the board
UART-0_RX_1V8: J1.101; also elsewhere on the board
UART-0_TX_1V8: J1.99; also elsewhere on the board
UART-1_CTS_1V8: J1.209; also elsewhere on the board
UART-1_RTS_1V8: J1.207; also elsewhere on the board
UART-1_RX_1V8: J1.205; also elsewhere on the board
UART-1_TX_1V8: J1.203; also elsewhere on the board
UART-2_RX_1V8: J1.238; also elsewhere on the board
UART-2_TX_1V8: J1.236; also elsewhere on the board
USB3-0-DN: J1.109; also elsewhere on the board
USB3-0-DP: J1.111; also elsewhere on the board
USB3-0-RX_N: J1.161; also elsewhere on the board
USB3-0-RX_P: J1.163; also elsewhere on the board
USB3-0-TX_N: J1.166; also elsewhere on the board
USB3-0-TX_P: J1.168; also elsewhere on the board
USB3-1-DN: J1.115; also elsewhere on the board
USB3-1-DP: J1.117; also elsewhere on the board
USB3-1-RX_N: J1.39; also elsewhere on the board
USB3-1-RX_P: J1.41; also elsewhere on the board
USB3-1-TX_N: J1.45; also elsewhere on the board
USB3-1-TX_P: J1.47; also elsewhere on the board
VBAT: J1.235; also elsewhere on the board
dCSI-0_CLK_N: J1.10; also elsewhere on the board
dCSI-0_CLK_P: J1.12; also elsewhere on the board
dCSI-0_D0_N: J1.4; also elsewhere on the board
dCSI-0_D0_P: J1.6; also elsewhere on the board
dCSI-0_D1_N: J1.16; also elsewhere on the board
dCSI-0_D1_P: J1.18; also elsewhere on the board
dCSI-0_D2_N: J1.3; also elsewhere on the board
dCSI-0_D2_P: J1.5; also elsewhere on the board
dCSI-0_D3_N: J1.15; also elsewhere on the board
dCSI-0_D3_P: J1.17; also elsewhere on the board
dCSI-1_CLK_N: J1.28; also elsewhere on the board
dCSI-1_CLK_P: J1.30; also elsewhere on the board
dCSI-1_D0_N: J1.22; also elsewhere on the board
dCSI-1_D0_P: J1.24; also elsewhere on the board
dCSI-1_D1_N: J1.34; also elsewhere on the board
dCSI-1_D1_P: J1.36; also elsewhere on the board
dCSI-1_D2_N: J1.21; also elsewhere on the board
dCSI-1_D2_P: J1.23; also elsewhere on the board
dCSI-1_D3_N: J1.33; also elsewhere on the board
dCSI-1_D3_P: J1.35; also elsewhere on the board
dHDMI-0_CLK_N: J1.81; also elsewhere on the board
dHDMI-0_CLK_P: J1.83; also elsewhere on the board
dHDMI-0_TX0_N: J1.75; also elsewhere on the board
dHDMI-0_TX0_P: J1.77; also elsewhere on the board
dHDMI-0_TX1_N: J1.69; also elsewhere on the board
dHDMI-0_TX1_P: J1.71; also elsewhere on the board
dHDMI-0_TX2_N: J1.63; also elsewhere on the board
dHDMI-0_TX2_P: J1.65; also elsewhere on the board
dUSB_N: J1.121; also elsewhere on the board
dUSB_P: J1.123; also elsewhere on the board

Notes on the sheet:
< Research cluster board implement

Parts:
Module1: 10164227-1004A1RLF; Raspberry-Pi-4-Compute-Module-B; MPN 2x DF40C-100DS-0.4V; Digi-Key_PN 2x H11615CT-ND

Connections:
CSI-0_CLK_N: Module1.127 (CAM1_C_N); also elsewhere on the board
CSI-0_CLK_P: Module1.129 (CAM1_C_P); also elsewhere on the board
CSI-0_D0_N: Module1.115 (CAM1_D0_N); also elsewhere on the board
CSI-0_D0_P: Module1.117 (CAM1_D0_P); also elsewhere on the board
CSI-0_D1_N: Module1.121 (CAM1_D1_N); also elsewhere on the board
CSI-0_D1_P: Module1.123 (CAM1_D1_P); also elsewhere on the board
CSI-0_D2_N: Module1.133 (CAM1_D2_N); also elsewhere on the board
CSI-0_D2_P: Module1.135 (CAM1_D2_P); also elsewhere on the board
CSI-0_D3_N: Module1.139 (CAM1_D3_N); also elsewhere on the board
CSI-0_D3_P: Module1.141 (CAM1_D3_P); also elsewhere on the board
CSI-1_CLK_N: Module1.187 (DSI1_C_N); also elsewhere on the board
CSI-1_CLK_P: Module1.189 (DSI1_C_P); also elsewhere on the board
CSI-1_D0_N: Module1.175 (DSI1_D0_N); also elsewhere on the board
CSI-1_D0_P: Module1.177 (DSI1_D0_P); also elsewhere on the board
CSI-1_D1_N: Module1.181 (DSI1_D1_N); also elsewhere on the board
CSI-1_D1_P: Module1.183 (DSI1_D1_P); also elsewhere on the board
CSI-1_D2_N: Module1.193 (DSI1_D2_N); also elsewhere on the board
CSI-1_D2_P: Module1.195 (DSI1_D2_P); also elsewhere on the board
CSI-1_D3_N: Module1.194 (DSI1_D3_N); also elsewhere on the board
CSI-1_D3_P: Module1.196 (DSI1_D3_P); also elsewhere on the board
GND: Module1.107 (GND), Module1.108 (GND), Module1.113 (GND), Module1.114 (GND), Module1.119 (GND), Module1.120 (GND), Module1.125 (GND), Module1.126 (GND), Module1.131 (GND), Module1.132 (GND), Module1.137 (GND), Module1.138 (GND), Module1.144 (GND), Module1.150 (GND), Module1.155 (GND), Module1.156 (GND), Module1.161 (GND), Module1.162 (GND), Module1.167 (GND), Module1.168 (GND), Module1.173 (GND), Module1.174 (GND), Module1.179 (GND), Module1.180 (GND), Module1.185 (GND), Module1.186 (GND), Module1.191 (GND), Module1.192 (GND), Module1.197 (GND), Module1.198 (GND); also elsewhere on the board
HDMI-0_CEC: Module1.151 (HDMI0_CEC); also elsewhere on the board
HDMI-0_CLK_N: Module1.190 (HDMI0_CLK_N); also elsewhere on the board
HDMI-0_CLK_P: Module1.188 (HDMI0_CLK_P); also elsewhere on the board
HDMI-0_HPD: Module1.153 (HDMI0_HOTPLUG); also elsewhere on the board
HDMI-0_SCL: Module1.200 (HDMI0_SCL); also elsewhere on the board
HDMI-0_SDA: Module1.199 (HDMI0_SDA); also elsewhere on the board
HDMI-0_TX0_N: Module1.184 (HDMI0_TX0_N); also elsewhere on the board
HDMI-0_TX0_P: Module1.182 (HDMI0_TX0_P); also elsewhere on the board
HDMI-0_TX1_N: Module1.178 (HDMI0_TX1_N); also elsewhere on the board
HDMI-0_TX1_P: Module1.176 (HDMI0_TX1_P); also elsewhere on the board
HDMI-0_TX2_N: Module1.172 (HDMI0_TX2_N); also elsewhere on the board
HDMI-0_TX2_P: Module1.170 (HDMI0_TX2_P); also elsewhere on the board
PCIe_CLKREQ: Module1.102 (PCIe_CLK_nREQ); also elsewhere on the board
PCIe_CLK_N: Module1.112 (PCIe_CLK_N); also elsewhere on the board
PCIe_CLK_P: Module1.110 (PCIe_CLK_P); also elsewhere on the board
PCIe_RX_N: Module1.118 (PCIe_RX_N); also elsewhere on the board
PCIe_RX_P: Module1.116 (PCIe_RX_P); also elsewhere on the board
PCIe_TX_N: Module1.124 (PCIe_TX_N); also elsewhere on the board
PCIe_TX_P: Module1.122 (PCIe_TX_P); also elsewhere on the board
PCIe_nRST: Module1.109 (PCIe_nRST); also elsewhere on the board
USB3-0-DN: Module1.136 (CAM0_D1_P); also elsewhere on the board
USB3-0-DP: Module1.134 (CAM0_D1_N); also elsewhere on the board
USB3-0-RX_N: Module1.128 (CAM0_D0_N); also elsewhere on the board
USB3-0-RX_P: Module1.130 (CAM0_D0_P); also elsewhere on the board
USB3-0-TX_N: Module1.140 (CAM0_C_N); also elsewhere on the board
USB3-0-TX_P: Module1.142 (CAM0_C_P); also elsewhere on the board
USB3-1-DN: Module1.165 (DSI0_D1_P); also elsewhere on the board
USB3-1-DP: Module1.163 (DSI0_D1_N); also elsewhere on the board
USB3-1-RX_N: Module1.157 (DSI0_D0_N); also elsewhere on the board
USB3-1-RX_P: Module1.159 (DSI0_D0_P); also elsewhere on the board
USB3-1-TX_N: Module1.169 (DSI0_C_N); also elsewhere on the board
USB3-1-TX_P: Module1.171 (DSI0_C_P); also elsewhere on the board
USB_N: Module1.103 (USB2_N); also elsewhere on the board
USB_P: Module1.105 (USB2_P); also elsewhere on the board

Parts:
C1, C2, C4, C5, C6: 0.1uF; C_0402_1005Metric
C7: 1uF; C_0402_1005Metric
C11, C20: 10uF; C_0603_1608Metric
D1: Green; LED_0805_2012Metric
D2: Yellow; LED_0805_2012Metric
J2: Micro_SD_Card_Det2; microSD_HC_Hirose_DM3AT-SF-PEJM5
Module2: 10164227-1004A1RLF; Raspberry-Pi-4-Compute-Module-A; MPN 2x DF40C-100DS-0.4V; Digi-Key_PN 2x H11615CT-ND
Q2, Q3, Q5: BSS138; SOT-23-3
Q4: BC817-40; SOT-323_SC-70
R1, R15: 330; R_0402_1005Metric
R10, R11, R12, R13, R16, R17, R18, R19, R20, R21, R24, R25: 10K; R_0402_1005Metric
R14: 12K; R_0402_1005Metric
SW1: SW_DIP_x04; SW_DIP_SPSTx04_Slide_Copal_CHS-04B_W7.62mm_P1.27mm
TP1: RTC Test; TestPoint_Pad_D1.0mm
TP2: Sleep Status Output; TestPoint_Pad_D1.0mm
U4: RT9742GGJ5; TSOT-23-5

Connections:
+1V8: Module2.88 (+1.8v_(Output)), Module2.90 (+1.8v_(Output)), R24.1; also elsewhere on the board
+3V3: Module2.84 (+3.3v_(Output)), Module2.86 (+3.3v_(Output)), Q2.2 (G), Q3.2 (G), Q5.2 (G), R1.1, R11.1, R13.1, R14.1, R15.1, R17.1, R18.1, R19.1, R20.1, R21.1, R25.1, U4.5 (VIN); also elsewhere on the board
+5V: C1.1, C2.1, C4.1, C5.1, C6.1, C7.1, C11.1, Module2.77 (+5v_(Input)), Module2.79 (+5v_(Input)), Module2.81 (+5v_(Input)), Module2.83 (+5v_(Input)), Module2.85 (+5v_(Input)), Module2.87 (+5v_(Input)), R10.1, R12.1; also elsewhere on the board
ACTIVITY_LED: D1.1 (K), Module2.21 (PI_nLED_Activity)
CSI-0_PWDN: Module2.24 (GPIO26); also elsewhere on the board
CSI-0_SCL: Module2.80 (SCL0); also elsewhere on the board
CSI-0_SDA: Module2.82 (SDA0); also elsewhere on the board
CSI-1_PWDN: Module2.97 (Camera_GPIO); also elsewhere on the board
FAN_PWM_3V3: Module2.19 (Ethernet_nLED1(3.3v)); also elsewhere on the board
FAN_TACH_3V3: Module2.16 (Ethernet_SYNC_IN(1.8v)); also elsewhere on the board
GBE_LED_ACT: Module2.17 (Ethernet_nLED2(3.3v)); also elsewhere on the board
GBE_LED_LINK: Module2.15 (Ethernet_nLED3(3.3v)); also elsewhere on the board
GBE_MDI0_N: Module2.10 (Ethernet_Pair0_N); also elsewhere on the board
GBE_MDI0_P: Module2.12 (Ethernet_Pair0_P); also elsewhere on the board
GBE_MDI1_N: Module2.6 (Ethernet_Pair1_N); also elsewhere on the board
GBE_MDI1_P: Module2.4 (Ethernet_Pair1_P); also elsewhere on the board
GBE_MDI2_N: Module2.9 (Ethernet_Pair2_N); also elsewhere on the board
GBE_MDI2_P: Module2.11 (Ethernet_Pair2_P); also elsewhere on the board
GBE_MDI3_N: Module2.5 (Ethernet_Pair3_N); also elsewhere on the board
GBE_MDI3_P: Module2.3 (Ethernet_Pair3_P); also elsewhere on the board
GND: C1.2, C2.2, C4.2, C5.2, C6.2, C7.2, C11.2, C20.2, J2.6 (VSS), J2.11 (SHIELD), Module2.1 (GND), Module2.2 (GND), Module2.7 (GND), Module2.8 (GND), Module2.13 (GND), Module2.14 (GND), Module2.22 (GND), Module2.23 (GND), Module2.32 (GND), Module2.33 (GND), Module2.42 (GND), Module2.43 (GND), Module2.52 (GND), Module2.53 (GND), Module2.59 (GND), Module2.60 (GND), Module2.65 (GND), Module2.66 (GND), Module2.71 (GND), Module2.74 (GND), Module2.98 (GND), Q4.3 (E), SW1.1, SW1.2, SW1.3, SW1.4, U4.2 (GND); also elsewhere on the board
GPIO0_3V3: Module2.48 (GPIO27); also elsewhere on the board
I2C-0_SCL: Module2.47 (GPIO23); also elsewhere on the board
I2C-0_SDA: Module2.46 (GPIO22); also elsewhere on the board
LED_PWR: Module2.95 (nPI_LED_PWR), R16.2
MOD_PWR_REQ: Module2.29 (GPIO16), Q3.3 (S), R13.2
MOD_SLEEP: Module2.30 (GPIO6), TP2.1; also elsewhere on the board
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R15.2
unnamed: D2.1 (K), Q4.1 (C)
unnamed: Q4.2 (B), R16.1
PMIC_EN: Module2.99 (Global_EN), Q2.3 (S), R11.2, SW1.7
POWER_BMC: Q2.1 (D), R10.2; also elsewhere on the board
PWR_Button: Module2.92 (RUN_PG), SW1.8
RESET_BMC: Q5.1 (D), R24.2; also elsewhere on the board
SD_CLK: J2.5 (CLK), Module2.57 (SD_CLK)
SD_CMD: J2.3 (CMD), Module2.62 (SD_CMD), R20.2
SD_DAT0: J2.7 (DAT0), Module2.63 (SD_DAT0), R18.2
SD_DAT1: J2.8 (DAT1), Module2.67 (SD_DAT1), R17.2
SD_DAT2: J2.1 (DAT2), Module2.69 (SD_DAT2), R21.2
SD_DAT3: J2.2 (DAT3/CD), Module2.61 (SD_DAT3), R19.2
SD_PWR: C20.1, J2.4 (VDD), U4.1 (VOUT)
SD_PWR_ON: Module2.75 (SD_PWR_ON), R14.2, U4.4 (EN)
SHUT_REQ_BMC: Q3.1 (D), R12.2; also elsewhere on the board
SLEEP/WAKE: Module2.45 (GPIO24); also elsewhere on the board
SPI-0_CLK_3V3: Module2.38 (GPIO11); also elsewhere on the board
SPI-0_CS0_3V3: Module2.39 (GPIO8); also elsewhere on the board
SPI-0_CS1_3V3: Module2.37 (GPIO7); also elsewhere on the board
SPI-0_MISO_3V3: Module2.40 (GPIO9); also elsewhere on the board
SPI-0_MOSI_3V3: Module2.44 (GPIO10); also elsewhere on the board
SPI-1_CLK_3V3: Module2.25 (GPIO21); also elsewhere on the board
SPI-1_CS0_3V3: Module2.49 (GPIO18); also elsewhere on the board
SPI-1_CS1_3V3: Module2.50 (GPIO17); also elsewhere on the board
SPI-1_MISO_3V3: Module2.26 (GPIO19); also elsewhere on the board
SPI-1_MOSI_3V3: Module2.27 (GPIO20); also elsewhere on the board
SYS_RESET: Module2.41 (GPIO25), Q5.3 (S), R25.2, SW1.5
UART-0_CTS_3V3: Module2.58 (GPIO2); also elsewhere on the board
UART-0_RTS_3V3: Module2.56 (GPIO3); also elsewhere on the board
UART-0_RX_3V3: Module2.35 (ID_SC); also elsewhere on the board
UART-0_TX_3V3: Module2.36 (ID_SD); also elsewhere on the board
UART-1_CTS_3V3: Module2.55 (GPIO14); also elsewhere on the board
UART-1_RTS_3V3: Module2.51 (GPIO15); also elsewhere on the board
UART-1_RX_3V3: Module2.28 (GPIO13); also elsewhere on the board
UART-1_TX_3V3: Module2.31 (GPIO12); also elsewhere on the board
UART-2_RX_3V3: Module2.34 (GPIO5); also elsewhere on the board
UART-2_TX_3V3: Module2.54 (GPIO4); also elsewhere on the board
VBAT: Module2.76 (Reserved), TP1.1; also elsewhere on the board
nRPIBOOT: Module2.93 (nRPIBOOT), SW1.6

Notes on the sheet:
Switching IO's
Status/Activity LED's
Hard Off/On
Soft Off
Shift 5V Shutdown Req to 3V3 Shutdown! Mod -> Carrier
Carrier 5V analog triggering PMIC on mod
SD Card
Test Points
Misc Buttons
As many 0.1uF as can fit, a 10uF/1uF for bulk
No Reset Button on CM5, but programmable through GPIO!
Reset
Sleep Status Output >
RPI Server Boot

Notices in the files:
PCB_CARRIER/carrier.kicad_pcb:
creativecommons.org/licenses/by/4.0
License: CC BY 4.0
